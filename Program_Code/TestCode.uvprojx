# Keil uVision project TestCode.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TestCode +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f303xe.s stm32f303xe.h SysClock.c SysClock.h system_stm32f3xx.c main.c LCD.c LCD.h LCDcommands.h macros.h stepper.c stepper.h Test.c Test.h Servo.c Servo.h Wheels.c Wheels.h Encoder.c Encoder.h RS232.h RS232.c
software components: CMSIS:CORE 5.1.2
